do_deploy_append() {
  cp ${B}/arch/${ARCH}/boot/${KERNEL_IMAGETYPE} ${DEPLOYDIR}
}
