do_compile_prepend() {
    mv ${DEPLOY_DIR_IMAGE}/initramfs-android-image-hammerhead.rootfs.cpio.gz ${DEPLOY_DIR_IMAGE}/initramfs-android-image-hammerhead.cpio.gz
}

